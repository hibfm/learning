# Keil uVision project ws281x led.uvprojx, settings and files
target ws281x led (ARM-ADS)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ws2812 led +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\pwm;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\CORE;..\HARDWARE\ws281x;..\HARDWARE\timer;..\HARDWARE\lanya;..\HARDWARE\oled;..\HARDWARE\RTC;..\HARDWARE\step
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group HARDWARE
    ../HARDWARE/pwm/: pwm.c
    ../HARDWARE/ws281x/: ws281x.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/oled/: OLED_I2C.c
    ../HARDWARE/lanya/: usart.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/step/: step.c
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_ld.s
